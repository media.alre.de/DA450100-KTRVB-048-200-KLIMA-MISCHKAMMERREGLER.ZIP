Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler, Heizen/Kühlen, Aufputz, 24 VAC/VDC, Ausgang 0…10 V / 10…0 V, 2-Rohr, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA450100, Raumtemperaturregler, Heizen/Kühlen, Aufputz, 24 VAC/VDC, Ausgang 0…10 V / 10…0 V, 2-Rohr
In: Raum
Description: Elektronischer Aufputz-Klimaregler zur Heiz- und Kühlregelung in Mischkammer in Hotel-, Wohn- und Geschäftsräumen. Zur Ansteuerung von stetigen Ventilantrieben oder Luftklappen. Der werkseitig eingestellte "Nullpunkt" von ca. 21 °C kann im Gerät um ±5 K verstellt werden. Mit dem Einstellknopf kann die Solltemperatur im Bereich von ±3 K um den eingestellten Nullpunkt verstellt werden.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA450100; ModelLabel: KTRVB-048.200; GlobalTradeItemNumber: 4050528028181; ProductURL: https://alre.de/produkt_DA450100
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.07
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 25.5; RAL-Nummer: 9010; Anschluss: drei-/vieradrig; Art der Spannungsversorgung: 24 V AC; Messbereich: 13; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Schutzart (NEMA): sonstige; Mit Empfänger: no; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 0.005; Differenzwert: 0; Sensor extern: no; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA450100.pdf
